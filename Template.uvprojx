# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\APP\led;.\Public;.\APP\buzzer;.\APP\relay;.\APP\key;.\APP\dht11;.\APP\oled;.\APP\ds18b20;.\APP\mpu6050;.\APP\step;.\APP\max30102
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c stm32f10x_it.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_iwdg.c stm32f10x_wwdg.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_rtc.c stm32f10x_can.c stm32f10x_fsmc.c stm32f10x_spi.c stm32f10x_i2c.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group APP
    ./APP/led/: led.h led.c
    ./APP/buzzer/: buzzer.h buzzer.c
    ./APP/relay/: relay.h relay.c
    ./APP/key/: key.h key.c
    ./APP/dht11/: dht11.h dht11.c
    ./APP/oled/: oled.h oled.c
    ./APP/ds18b20/: ds18b20.h ds18b20.c
    ./APP/mpu6050/: mpu6050.h mpu6050.c
    ./APP/step/: step.h step.c
    ./APP/max30102/: max30102.h max30102.c hr.h hr.c
  group Public
    ./Public/: system.c SysTick.c usart.c usart2.c
